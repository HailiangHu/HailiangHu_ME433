File: HW2/ME433HW2/433hw2.sch (EAGLE design)
At the start: 0 parts

Commit message: sch
Parts:
- added IC1: (no value), 433LIB:DIL28-4
